## samples/net/pps_out/boards/frdm_mcxn947_mcxn947_cpu0.conf
```kconfig
CONFIG_PTP_CLOCK_NXP_ENET_QOS_OUTPUT=y
CONFIG_PRECISION_CLOCK_PPS_WIDTH_PROVIDER_DEFAULT=y
```
